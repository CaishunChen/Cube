# Keil uVision project Cube.uvprojx, settings and files
target Cube (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Aircraft_STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE
  c misc: --C99
  c include: ..\inc;..\inc\driver;..\inc\xtos;..\lib\cmsis\inc;..\lib\stm32f411\inc;..\lib\utils\inc;..\lib\eMPL\inc;.\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group app
    ./app/: main.c interrupts.c command.c gVariables.c cube.c
  group libstm32
    ../lib/stm32f411/src/: startup_stm32f411xe.s system_stm32f4xx.c stm32f4xx_gpio.c stm32f4xx_timer.c stm32f4xx_usart.c
  group driver
    ../driver/: led.c motor.c system.c fakei2c.c usart.c timer.c
  group libutils
    ../lib/utils/src/: utils.c matrix.c queue.c stdio.c list.c pid.c
  group libeMPL
    ../lib/eMPL/src/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c
  group xtos
    ../xtos/: xtos.c xtos_time.c xtos_asm.s
software components: CMSIS:CORE 4.1.0
